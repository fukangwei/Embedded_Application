# Keil uVision project ENC28J60.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ENC28J60 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\SPI;..\HARDWARE\ENC28J60;..\HARDWARE\TIMER;..\LWIP-SRC\include\ipv4;..\LWIP-SRC\include;..\LWIP-APP;..\LWIP-APP\config;..\LWIP-APP\udp;..\LWIP-APP\config
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ENC28J60/: enc28j60.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timerx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: mysys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_i2c.c
  group LWIP-API
    ../LWIP-SRC/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP-CORE
    ../LWIP-SRC/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../LWIP-SRC/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP-NETIF
    ../LWIP-SRC/netif/: etharp.c ethernetif.c
  group LWIP_ARCH
    ../LWIP-APP/arch/: bpstruct.h cc.h cpu.h epstruct.h init.h lib.h perf.h sys_arch.c sys_arch.h
  group LWIP-APP
    ../LWIP-APP/udp/: udp_client.c udp_server.c
    ../LWIP-APP/config/: lwip_demo.c
